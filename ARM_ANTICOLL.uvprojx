# Keil uVision project ARM_ANTICOLL.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ARM_ANTICOLL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\cmsis\CMSIS\Include;.\cmsis\Device\ARM\CMSDK_CM0\Include;.\retarget;..\arm-anticoll - dualifc;.\CMD;.\System;.\HAL
  memory RVCT4: ROM 0x0 size 0x3f400
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Main
    ./: mainapp.c
  group HAL
    ./HAL/: flash.c HAL_Init.c vuaes.c vutdes.c XSIM_Hard_Api.c startup_CMSDK_CM0.s
  group System
    ./System/: System_Dispatcher.c System_SendATR.c firmware.c VUISO14443.c
  group CMD
    ./CMD/: auth_aes.c auth_des.c change_file_set.c create_app.c create_file.c format_picc.c get_file_id.c get_file_set.c read_data.c rw_aes.c sel_app.c write_data.c change_key.c chgkey_aes.c delete_app.c get_app.c get_key_set.c get_key_ver.c get_ver.c iso_read.c iso_select.c iso_write.c
